# IAR project sysloader-QSPI.ewp, settings and files
configuration Rel (ARM)
  General.OGChipSelectEditMenu: LPC1766 NXP LPC1766
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; PCB_BASE=0; FDEBUG_EN=0; FDBG_USERX=0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --aeabi; --guard_calls
  ICCARM.CCIncludePath2: $PROJ_DIR$; hw-cfg; drivers; ..\common; ..\ASM9260T
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  AARM.AUserIncludes: $PROJ_DIR$; hw-cfg; ..\common; ..\ASM9260T
  OBJCOPY.OOCOutputFile: sysloader-QSPI.bin
  ILINK.IlinkOutputFile: sysloader-QSPI.out
  ILINK.IlinkIcfFile: hw-cfg\ld.icf
  ILINK.IlinkExtraOptions: --redirect free=lwm_free; --redirect malloc=lwm_alloc; --redirect calloc=lwm_calloc
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common
    ../ASM9260T/: gpio.c gpio.h pinmux.c pinmux.h
  group device
    ../ASM9260T/: ASM9260T.h mmu.c mmu.h mmu_a.s toolbox_a.s
  group myworks
    ./: cstartup.s drivers.c usrentry.c usrinc.h
  group myworks/drivers/clkout
    drivers/clkout/: clkout.c clkout.h
  group myworks/drivers/led
    drivers/led/: led.c led.h
  group myworks/drivers/qspi
    drivers/qspi/: qspi.c qspi.h
  group myworks/hw-cfg
    hw-cfg/: ld.icf
