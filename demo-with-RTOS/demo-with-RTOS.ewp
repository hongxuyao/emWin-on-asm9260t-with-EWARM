# IAR project demo-with-RTOS.ewp, settings and files
configuration Rel (ARM)
  General.OGChipSelectEditMenu: LPC1766 NXP LPC1766
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --aeabi; --guard_calls
  ICCARM.CCIncludePath2: $PROJ_DIR$; hw-cfg; drivers; ..\common; ..\ASM9260T; ..\third-party\emwin
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: NDEBUG
  AARM.AUserIncludes: $PROJ_DIR$; hw-cfg; ..\common; ..\ASM9260T
  OBJCOPY.OOCOutputFile: demo-with-RTOS.bin
  postbuild: $EXE_DIR$\XCryptImage.exe -Usysloader -F$TARGET_BNAME$.bin
  ILINK.IlinkOutputFile: demo-with-RTOS.out
  ILINK.IlinkIcfFile: hw-cfg\ld.icf
  ILINK.IlinkExtraOptions: --redirect free=lwm_free; --redirect malloc=lwm_alloc; --redirect calloc=lwm_calloc
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group common
    ../common/: frmentry.c ftypes.h os_core.c os_cpu.h os_cpu_a.s os_cpu_c.c os_dbg.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group device
    ../ASM9260T/: ASM9260T.h cstartup_ASM9260T.s gpio.c gpio.h icoll.c icoll.h mmu.c mmu.h mmu_a.s pinmux.c pinmux.h targetinc.h timer0.c timer0.h toolbox_a.s
  group myworks
    ./: drivers.c usrentry.c usrinc.h
  group myworks/drivers/lcd
    drivers/lcd/: lcdhw.c lcdhw.h
  group myworks/drivers/led
    drivers/led/: led.c led.h
  group myworks/hw-cfg
    hw-cfg/: ld.icf os_cfg.h
  group myworks/tsk-gui
    tsk-gui/: task_gui.c
  group myworks/tsk-gui/Demo
    tsk-gui/Demo/: GUIDEMO.c GUIDEMO.h GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group third-party/emwin
    ../third-party/emwin/: emWin.a GUI_X_uCOS.c LCDConf.c
